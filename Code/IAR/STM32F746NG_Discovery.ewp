# IAR project STM32F746NG_Discovery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; NDEBUG
  ICCARM.CCIncludePath2: ..\User; ..\BSP; ..\BSP\led; ..\BSP\timer; ..\BSP\button; ..\BSP\CMSIS; ..\BSP\IAR; ..\CMSIS\Device\ST\STM32F7xx\Include; ..\STM32F7xx_HAL_Driver\Inc; ..\STM32F7xx_HAL_Driver\Inc\Legacy; ..\STM32F7xx_HAL_Driver\Src; ..\uCOS-III\uC-CPU; ..\uCOS-III\uC-CPU\ARM-Cortex-M7\IAR; ..\uCOS-III\uC-LIB; ..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M7\IAR; ..\uCOS-III\uCOS-III\Source; ..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M7\Generic\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F746NG_Discovery.srec
  ILINK.IlinkOutputFile: STM32F746NG_Discovery.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f746xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../User/: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f7xx_hal_conf.h
    ../STM32F7xx_HAL_Driver/Src/: stm32f7xx_it.c
  group BSP
    ../BSP/: bsp.c bsp.h cpu_bsp.c
    ../BSP/button/: bsp_button.c
    ../BSP/led/: bsp_led.c
    ../BSP/timer/: bsp_timer.c
  group BSP/CMSIS
    ../BSP/CMSIS/: system_stm32f7xx.c
  group BSP/IAR
    ../BSP/IAR/: cstartup.c STM32F746xx_FLASH.icf
  group STM32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Include
    ../CMSIS/Device/ST/STM32F7xx/Include/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f746xx.h stm32f7xx.h system_stm32f7xx.h
  group STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc
    ../STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_cortex.h stm32f7xx_hal_def.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h
  group STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy
    ../STM32F7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src
    ../STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group uC/CPU
    ../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M7/IAR
    ../uCOS-III/uC-CPU/ARM-Cortex-M7/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M7/IAR
    ../uCOS-III/uC-LIB/Ports/ARM-Cortex-M7/IAR/: lib_mem_a.asm
  group uC/OS-III/Ports/ARM-Cortex-M7/Generic/IAR
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M7/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
